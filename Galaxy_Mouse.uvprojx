# Keil uVision project Galaxy_Mouse.uvprojx, settings and files
target Mouse (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: SN32F247BF SONiX
  pack: SONiX.SN32F2_DFP.1.2.8
  cpu: IROM(0x00000000,0xFFFC) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Galaxy_Mouse +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source\Driver;.\Source\UserApp;.\Source\LED;.\Source\Mouse;.\Source\Utility;.\Source\Usb;.\Source\UsbHid
  memory RVCT4: ROM 0x0 size 0xf800
  memory RVCT5: ROM 0xfc00 size 0x3fc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Driver
    ./Source/Driver/: CT16B1.c FlashPrg.c SPI0.c CT16B0.c
  group LED
    ./Source/LED/: LED.c LED_Function.c LED_RamSetting.c LED_Table.c
  group Mouse
    ./Source/Mouse/: Boot_Idle_State.c Mouse.c Mouse_Function.c Mouse_RamSetting.c Mouse_Sensor.c Mouse_Table.c avago_api.c Mouse_Key.c Mouse_Wheel.c
  group Usb
    ./Source/Usb/: usbdesc.c usbepfunc.c usbhw.c usbram.c usbuser.c
  group UsbHid
    ./Source/UsbHid/: hidram.c hiduser.c
  group UserApp
    ./Source/UserApp/: main.c variables.c usb_protocol.c
  group Utility
    ./Source/Utility/: Utility.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.1.0
